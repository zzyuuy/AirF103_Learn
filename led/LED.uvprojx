# Keil uVision project LED.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: AIR32F103CB Generic
  pack: Keil.AIR32F103_DFP.1.0.6
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\AIR32F10xLib\inc;.\CMSIS\Include;..\led;.\CORE
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ./: main.c
    ./AIR32F10xLib/src/: system_air32f10x.c
  group system
    ./AIR32F10xLib/src/: air32f10x_gpio.c air32f10x_rcc.c air32f10x_usart.c misc.c
    ./CORE/: core_cm3.c
